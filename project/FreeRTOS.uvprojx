# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_PRESENT=1,__FPU_USED =1
  c include: ..\application\inc;..\utilities\inc;..\driver\inc;..\rtos\include;..\rtos\portable\RVDS\ARM_CM4F;..\rtos_fs\include;..\rtos_fs\portable\common;..\rtos_fs\portable\STM32F4xx
  asm include: ..\application\inc;..\utilities\inc;..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ../application/src/: main.c led_app.c usart_app.c beep_app.c freertos_app.c rtc_app.c
  group utilities
    ../utilities/src/: startup_stm32f40_41xxx.s stm32f4xx_it.c stm324xg_eval.c system_stm32f4xx.c
  group driver
    ../driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_i2c.c stm32f4xx_syscfg.c stm32f4xx_sdio.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group rtos
    ../rtos/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../rtos/portable/MemMang/: heap_4.c
    ../rtos/portable/RVDS/ARM_CM4F/: port.c
  group rtos_fs
    ../rtos_fs/: ff_crc.c ff_dir.c ff_error.c ff_fat.c ff_file.c ff_format.c ff_ioman.c ff_locking.c ff_memory.c ff_stdio.c ff_string.c ff_sys.c ff_time.c
    ../rtos_fs/portable/common/: ff_ramdisk.c
    ../rtos_fs/portable/STM32F4xx/: ff_sddisk.c stm32f4xx_hal_sd.c
